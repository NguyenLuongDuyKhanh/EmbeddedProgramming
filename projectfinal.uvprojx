# Keil uVision project projectfinal.uvprojx, settings and files
target ShipShooting (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: projectfinal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drv\inc;.\RTOS\include;.\RTOS\portable\RVDS\ARM_CM0;..\Beta;.\Ethernet;..\EmbeddedProgramming;.\EthernetQuanGui;.\InternetProtocol;.\W5500;.\W5500\W5500;.\loopback;.\mbed\WIZnetInterface;.\mbed\WIZnetInterface\WIZnet
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c FreeRTOSConfig.h
  group RTOS
    ./RTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ./RTOS/portable/RVDS/ARM_CM0/: port.c
    ./RTOS/portable/MemMang/: heap_1.c
  group Drv
    ./Drv/src/: adc.c bpwm.c can.c clk.c fmc.c gpio.c i2c.c pwm.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group Ethernet
    ./Ethernet/: STM_ENC28_J60.c STM_ENC28_J60.h
  group EthernetQuan
    ./EthernetQuanGui/: ENC28J60.C ENC28J60.H
  group IP
    ./InternetProtocol/: ip_arp_udp_tcp.c ip_arp_udp_tcp.h net.h
  group W5500mbed
    ./mbed/WIZnetInterface/: pico_string.h WIZnetInterface.cpp WIZnetInterface.h
    ./mbed/WIZnetInterface/WIZnet/: W5500.cpp W5500.h
software components: CMSIS:CORE 5.3.0, Device:Startup 0.00.001
